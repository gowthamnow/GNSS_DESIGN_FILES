File: GNSS.kicad_pcb (KiCad board)
At the start: 2 copper layers, 101 x 53 mm, 147 parts, among them IC1 USB2513B_M2, IC2 ZED-F9P-05B, IC3 STM32H563VGT6, J1 USB4105-GF-A, J2 USB4105-GF-A, J3 5033981892, J5 Conn_01x05_Pin, J6 Conn, J7 Conn, T1 WE-RJ45_7499010211A, U1 ICM-42688-P, U3 ESP32-C3-MINI-1-N4, U4 DP83825IRMQR, U5 TCAN1042VDRBRQ1, U6 ADP150WACBZ-3.3-R7, U7 IR3883MTRPBF, U8 ECS-TXO-2520-33-240-AN-TR, Y2 ECS-250-12-33-AGN-TR

Commit message: schematics
Parts:
- removed the R10 at (257.9, 23.3)
- removed the R10 at (185.4, 113.1)
- removed the R18 at (135.4, 123.2)
- removed the R18 at (263.6, 35.6)
- removed R43: 10K, Resistor_SMD:R_0805_2012Metric
- removed the R8 at (185.4, 109.2)
- removed the R8 at (257.9, 21.3)
- removed the TP3 at (203.9, 53.3)
- removed the TP3 at (272.7, 25.4)
- added C11: 1uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (95.1, 79.9)
- added C12: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 82.9)
- added C13: 1uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (95.1, 82.9)
- added C14: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 84.9)
- added C29: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.0, 63.1)
- added C30: 10nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.0, 65.1)
- added C32: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.4, 34.1)
- added C33: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.4, 36.1)
- added C34: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.4, 38.1)
- added C35: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.4, 40.0)
- added C36: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (110.3, 34.1)
- added C37: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (110.3, 36.1)
- added C38: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (110.3, 38.1)
- added C39: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (110.3, 40.0)
- added C4: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 71.1)
- added C40: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (113.1, 34.1)
- added C41: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (113.1, 36.1)
- added C42: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (113.1, 38.1)
- added C5: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 73.1)
- added C54: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (59.0, 110.3)
- added C56: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (59.0, 112.3)
- added C6: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 75.0)
- added C63: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (59.0, 114.2)
- added C69: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (102.8, 112.4)
- added C7: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 77.0)
- added C75: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (107.0, 67.0)
- added C8: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 79.0)
- added C82: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (113.1, 40.0)
- added C9: 0.1uF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (85.6, 81.0)
- added R10: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (88.5, 79.1)
- added R18: 560R, Resistor_SMD:R_0805_2012Metric, F.Cu at (32.8, 90.7)
- added R22: 22E, Resistor_SMD:R_0805_2012Metric, F.Cu at (86.4, 22.0)
- added R8: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (88.5, 77.1)
- added R94: 10K, Resistor_SMD:R_0805_2012Metric, F.Cu at (113.9, 102.5)
- added TP3: TestPoint, TestPoint:TestPoint_Pad_D2.0mm, F.Cu at (103.4, 109.4)
- added U10: TPD2EUSB30ADRTR, GNSS:SOTFL35P100X50-3N, F.Cu at (20.5, 123.0)
- added U11: TPD2EUSB30ADRTR, GNSS:SOTFL35P100X50-3N, F.Cu at (20.5, 125.6)
- added U12: TPD2EUSB30ADRTR, GNSS:SOTFL35P100X50-3N, F.Cu at (20.5, 128.2)
- added U2: TPD2EUSB30ADRTR, GNSS:SOTFL35P100X50-3N, F.Cu at (21.0, 120.5)
- R38, R39, R40, R41: value 10]K -> 10K
- R9: value 100K -> 10K; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0805_2012Metric
- moved TP1 248.4 mm to (25.7, 91.2)
- moved R83 242.0 mm to (43.6, 122.6)
- moved R31 237.3 mm to (32.8, 93.7)
- moved R92 237.3 mm to (32.8, 96.6)
- moved R32 234.0 mm to (51.7, 112.3)
- moved R80 234.0 mm to (51.7, 114.3)
- moved R81 234.0 mm to (51.7, 116.3)
- moved R82 234.0 mm to (51.7, 118.3)
- moved R84 232.1 mm to (48.0, 110.8)
- moved R85 232.1 mm to (48.0, 113.8)
- moved R86 232.1 mm to (48.0, 116.7)
- moved C81 187.9 mm to (109.5, 114.5)
- moved U6 185.8 mm to (16.8, 117.5)
- moved TP2 184.1 mm to (25.7, 95.3)
- moved C15 183.1 mm to (7.93, 90.7)
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Connections:
- net SCK renamed IMU_SCK
- A1 pad 29: USB_SCL -> GND
- A1 pad 6: USB_SCL -> GND
- A1 pad 7: USB_SCL -> GND
- A1 pad 8: VIN -> unconnected-(A1-VIN-Pad8)
- C15 pad 2: USB_SCL -> GND
- C16 pad 2: USB_SCL -> GND
- C19 pad 2: USB_SCL -> GND
- C20 pad 2: USB_SCL -> GND
- C22 pad 2: USB_SCL -> GND
- C23 pad 2: USB_SCL -> GND
- C25 pad 2: USB_SCL -> GND
- C26 pad 1: USB_SCL -> GND
- C43 pad 2: USB_SCL -> GND
- C45 pad 2: USB_SCL -> GND
- C46 pad 2: USB_SCL -> GND
- C48 pad 2: USB_SCL -> GND
- C51 pad 2: USB_SCL -> GND
- C52 pad 2: USB_SCL -> GND
- C53 pad 2: USB_SCL -> GND
- C55 pad 2: USB_SCL -> GND
- C57 pad 2: USB_SCL -> GND
- C58 pad 2: USB_SCL -> GND
- C62 pad 2: USB_SCL -> GND
- C67 pad 2: USB_SCL -> GND
- C70 pad 2: USB_SCL -> GND
- C76 pad 2: USB_SCL -> GND
- C78 pad 1: +3.3V -> STM_3.3V
- C78 pad 2: USB_SCL -> GND
- C79 pad 2: USB_SCL -> GND
- C81 pad 2: USB_SCL -> GND
- D3 pad 2: USB_SCL -> GND
- D4 pad 2: USB_SCL -> GND
- D7 pad 3: USB_SCL -> GND
- IC1 pad 11: USB_SCL -> GND
- IC1 pad 22: Net-(IC1-SDA/SMBDATA/NON_REM1) -> USB_SDA
- IC1 pad 24: Net-(IC1-SCL/SMBCLK/CFG_SEL0) -> USB_SCL
- IC1 pad 37: USB_SCL -> GND
- IC2 pad 1: USB_SCL -> GND
- IC2 pad 100: USB_SCL -> GND
- IC2 pad 101: USB_SCL -> GND
- IC2 pad 102: USB_SCL -> GND
- IC2 pad 12: USB_SCL -> GND
- IC2 pad 14: USB_SCL -> GND
- IC2 pad 3: USB_SCL -> GND
- IC2 pad 32: USB_SCL -> GND
- IC2 pad 37: USB_SCL -> GND
- IC2 pad 38: PG_VBUS -> +3V3_GN
- IC2 pad 41: USB_SCL -> GND
- IC2 pad 42: GN_SDO -> GN_MISO
- IC2 pad 43: GN_SDI -> GN_MOSI
- IC2 pad 47: USB_SCL -> GND
- IC2 pad 48: USB_SCL -> GND
- IC2 pad 55: USB_SCL -> GND
- IC2 pad 56: USB_SCL -> GND
- IC2 pad 57: USB_SCL -> GND
- IC2 pad 58: USB_SCL -> GND
- IC2 pad 59: USB_SCL -> GND
- IC2 pad 60: USB_SCL -> GND
- IC2 pad 61: USB_SCL -> GND
- IC2 pad 62: USB_SCL -> GND
- IC2 pad 63: USB_SCL -> GND
- IC2 pad 64: USB_SCL -> GND
- IC2 pad 65: USB_SCL -> GND
- IC2 pad 66: USB_SCL -> GND
- IC2 pad 67: USB_SCL -> GND
- IC2 pad 68: USB_SCL -> GND
- IC2 pad 69: USB_SCL -> GND
- IC2 pad 70: USB_SCL -> GND
- IC2 pad 71: USB_SCL -> GND
- IC2 pad 72: USB_SCL -> GND
- IC2 pad 73: USB_SCL -> GND
- IC2 pad 74: USB_SCL -> GND
- IC2 pad 75: USB_SCL -> GND
- IC2 pad 76: USB_SCL -> GND
- IC2 pad 77: USB_SCL -> GND
- IC2 pad 78: USB_SCL -> GND
- IC2 pad 79: USB_SCL -> GND
- IC2 pad 80: USB_SCL -> GND
- IC2 pad 81: USB_SCL -> GND
- IC2 pad 82: USB_SCL -> GND
- IC2 pad 83: USB_SCL -> GND
- IC2 pad 84: USB_SCL -> GND
- IC2 pad 85: USB_SCL -> GND
- IC2 pad 86: USB_SCL -> GND
- IC2 pad 87: USB_SCL -> GND
- IC2 pad 88: USB_SCL -> GND
- IC2 pad 89: USB_SCL -> GND
- IC2 pad 90: USB_SCL -> GND
- IC2 pad 91: USB_SCL -> GND
- IC2 pad 92: USB_SCL -> GND
- IC2 pad 93: USB_SCL -> GND
- IC2 pad 94: USB_SCL -> GND
- IC2 pad 95: USB_SCL -> GND
- IC2 pad 96: USB_SCL -> GND
- IC2 pad 97: USB_SCL -> GND
- IC2 pad 98: USB_SCL -> GND
- IC2 pad 99: USB_SCL -> GND
- IC3 pad 10: USB_SCL -> GND
- IC3 pad 19: USB_SCL -> GND
- IC3 pad 20: USB_SCL -> GND
- IC3 pad 27: USB_SCL -> GND
- IC3 pad 4: SDI -> IMU_MISO
- IC3 pad 40: ETH_RST_N -> unconnected-(IC3-PE9-Pad40)
- IC3 pad 46: unconnected-(IC3-PE15-Pad46) -> ESP_BOOT
- IC3 pad 47: ESP_BOOT -> unconnected-(IC3-PB10-Pad47)
- IC3 pad 49: USB_SCL -> GND
- IC3 pad 5: SDO -> IMU_MOSI
- IC3 pad 57: AR_D4 -> AR_D6
- IC3 pad 58: AR_D5 -> AR_D8
- IC3 pad 59: AR_D6 -> USB_SCL
- IC3 pad 60: AR_D7 -> USB_SDA
- IC3 pad 61: AR_D8 -> AR_D5
- IC3 pad 62: AR_D9 -> AR_D4
- IC3 pad 63: unconnected-(IC3-PC6-Pad63) -> AR_D7
- IC3 pad 64: SD_DETECT -> AR_D9
- IC3 pad 67: unconnected-(IC3-PA8-Pad67) -> SD_DETECT
- IC3 pad 74: USB_SCL -> GND
- IC3 pad 87: GN_SDO -> GN_MOSI
- IC3 pad 90: GN_SDI -> GN_MISO
- IC3 pad 94: Net-(IC3-BOOT0) -> /Controller/BOOT0
- IC3 pad 99: USB_SCL -> GND
- J1 pad A1-B12: USB_SCL -> GND
- J1 pad A4-B9: PG_VBUS -> Net-(D3-K)
- J1 pad B1-A12: USB_SCL -> GND
- J2 pad A1-B12: USB_SCL -> GND
- J2 pad A4-B9: /Power/EX_VBUS -> Net-(D4-K)
- J2 pad B1-A12: USB_SCL -> GND
- J3 pad 6: USB_SCL -> GND
- J3 pad 9: USB_SCL -> GND
- J5 pad 5: USB_SCL -> GND
- J6 pad 3: USB_SCL -> GND
- J7 pad 3: USB_SCL -> GND
- R1 pad 2: USB_SCL -> GND
- R12 pad 2: USB_SCL -> GND
- R14 pad 2: USB_SCL -> GND
- R27 pad 2: +3.3V -> STM_3.3V
- R30 pad 2: +3.3V -> STM_3.3V
- R42 pad 1: Net-(IC3-BOOT0) -> /Controller/BOOT0
- R42 pad 2: /Controller/BOOT0 -> STM_3.3V
- R47 pad 1: USB_SCL -> GND
- R53 pad 1: SDI -> IMU_MOSI
- R54 pad 1: SDO -> IMU_MISO
- R6 pad 1: USB_SCL -> GND
- R62 pad 1: GN_SDO -> GN_MISO
- R63 pad 1: GN_SDI -> GN_MOSI
- R69 pad 2: USB_SCL -> GND
- R7 pad 2: USB_SCL -> GND
- R82 pad 1: USB_SCL -> GND
- R87 pad 1: USB_SCL -> GND
- R87 pad 2: Net-(IC1-SCL/SMBCLK/CFG_SEL0) -> USB_SCL
- R88 pad 1: USB_SCL -> GND
- R88 pad 2: Net-(IC1-SDA/SMBDATA/NON_REM1) -> USB_SDA
- R9 pad 1: USB_SCL -> Net-(IC1-SUSP_IND/LOCAL_PWR/NON_REM0)
- R9 pad 2: Net-(IC1-SUSP_IND/LOCAL_PWR/NON_REM0) -> +3.3V
- R90 pad 2: USB_SCL -> GND
- S1 pad 4: USB_SCL -> GND
- TP2 pad 1: USB_SCL -> GND
- U1 pad 1: SDO -> IMU_MISO
- U1 pad 14: SDI -> IMU_MOSI
- U1 pad 6: USB_SCL -> GND
- U3 pad 1: USB_SCL -> GND
- U3 pad 11: USB_SCL -> GND
- U3 pad 14: USB_SCL -> GND
- U3 pad 2: USB_SCL -> GND
- U3 pad 36: USB_SCL -> GND
- U3 pad 37: USB_SCL -> GND
- U3 pad 38: USB_SCL -> GND
- U3 pad 39: USB_SCL -> GND
- U3 pad 40: USB_SCL -> GND
- U3 pad 41: USB_SCL -> GND
- U3 pad 42: USB_SCL -> GND
- U3 pad 43: USB_SCL -> GND
- U3 pad 44: USB_SCL -> GND
- U3 pad 45: USB_SCL -> GND
- U3 pad 46: USB_SCL -> GND
- U3 pad 47: USB_SCL -> GND
- U3 pad 48: USB_SCL -> GND
- U3 pad 49_1: USB_SCL -> GND
- U3 pad 49_2: USB_SCL -> GND
- U3 pad 49_3: USB_SCL -> GND
- U3 pad 49_4: USB_SCL -> GND
- U3 pad 49_5: USB_SCL -> GND
- U3 pad 49_6: USB_SCL -> GND
- U3 pad 49_7: USB_SCL -> GND
- U3 pad 49_8: USB_SCL -> GND
- U3 pad 49_9: USB_SCL -> GND
- U3 pad 50: USB_SCL -> GND
- U3 pad 51: USB_SCL -> GND
- U3 pad 52: USB_SCL -> GND
- U3 pad 53: USB_SCL -> GND
- U4 pad 21: USB_SCL -> GND
- U4 pad 25: EXP -> GND
- U4 pad 26: EXP -> GND
- U4 pad 27: EXP -> GND
- U4 pad 28: EXP -> GND
- U4 pad 29: EXP -> GND
- U4 pad 30: EXP -> GND
- U4 pad 9: USB_SCL -> GND
- U5 pad 2: USB_SCL -> GND
- U5 pad 9: USB_SCL -> GND
- U6 pad B2: USB_SCL -> GND
- U7 pad 13_14: USB_SCL -> GND
- U7 pad 17: USB_SCL -> GND
- U7 pad 3: USB_SCL -> GND
- U7 pad 4: USB_SCL -> GND
- U8 pad 1: +3.3V -> STM_3.3V
- U8 pad 2: USB_SCL -> GND
- U8 pad 3: /Controller/OSC -> Net-(C66-Pad2)
- U8 pad 4: +3.3V -> STM_3.3V
- VR1 pad 11: USB_SCL -> GND
- VR1 pad 5: USB_SCL -> GND
- VR1 pad 8: USB_SCL -> GND
- Y2 pad 2: USB_SCL -> GND
- Y2 pad 4: USB_SCL -> GND
Routing:
- net GND: track 0.00 -> 6.05 mm
Other:
- board outline removed

Commit message: placed
Parts:
- removed C53: 1uF, Capacitor_SMD:C_0805_2012Metric
- removed C54: 100nF, Capacitor_SMD:C_0402_1005Metric
- removed R77: 10K, Resistor_SMD:R_0805_2012Metric
- added BT1: 1056, 1056:BAT_1056, B.Cu at (131.4, 7.74)
- added C1: 18pF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (50.4, 27.4)
- added C10: 4.7uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (73.7, 30.2)
- added C17: 220pF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (46.7, 9.60)
- added C18: 0.1uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (67.9, 12.2)
- added C2: 18pF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (47.4, 27.6)
- added C21: 0.1uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (76.2, -1.18)
- added C24: 0.47, Capacitor_SMD:C_0402_1005Metric, F.Cu at (117.6, 16.3)
- added C27: 27pF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (126.3, 27.1)
- added C28: 0.1uF, Capacitor_SMD:C_0402_1005Metric, B.Cu at (90.7, 42.1)
- added C3: 0.1uF, C0402C104K4RAC:CAPC1005X55N, B.Cu at (75.6, 21.2)
- added C31: 0.1uF, Capacitor_SMD:C_0402_1005Metric, B.Cu at (90.7, 43.2)
- added C44: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (94.9, -20.6)
- added C47: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (94.9, -18.5)
- added C49: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (94.9, -16.4)
- added C50: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (94.9, -14.3)
- added C59: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (120.1, 35.6)
- added C60: 100nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (127.3, 37.8)
- added C61: 10nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (129.4, 37.8)
- added C64: 10nF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (129.4, 38.9)
- added C65: 27pF, Capacitor_SMD:C_0402_1005Metric, F.Cu at (130.2, 32.0)
- added C66: 15pF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (85.7, 19.5)
- added C68: 4.7nF, C0402C104K4RAC:CAPC1005X55N, B.Cu at (101.3, 1.51)
- added C71: GRM033R71C103KE14D, GRM033R71C103KE14D:CAPC0603X33N, F.Cu at (144.1, 2.12)
- added C72: 1uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (69.1, 21.2)
- added C73: 100pF, C0402C104K4RAC:CAPC1005X55N, B.Cu at (102.3, 3.55)
- added C74: 100pF, C0402C104K4RAC:CAPC1005X55N, B.Cu at (100.1, 5.13)
- added C77: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (94.9, -10.1)
- added C80: 100nF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (228.1, 93.8)
- added C83: 0.1uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (106.3, 2.53)
- added C84: 0.1uF, C0402C104K4RAC:CAPC1005X55N, F.Cu at (106.3, 3.71)
- added D1: PESD0402-140, PESD0402-140:DIO_PESD0402-140, F.Cu at (145.9, -2.63)
- added FL1: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (91.5, 45.0)
- added FL10: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (73.7, 21.6)
- added FL11: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (119.4, 37.7)
- added FL12: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (228.8, 91.3)
- added FL13: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (87.0, 10.5)
- added FL2: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (94.6, 1.26)
- added FL3: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (98.8, -0.16)
- added FL4: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (82.9, 6.33)
- added FL5: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (107.9, 28.3)
- added FL6: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (94.5, 3.29)
- added FL7: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, B.Cu at (88.8, 8.47)
- added FL8: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (76.0, 0.62)
- added FL9: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N, F.Cu at (109.8, -1.02)
- added J4: SMA-J-P-X-RA-TH1, GNSS:SAMTEC_SMA-J-P-X-RA-TH1, F.Cu at (151.4, -1.43)
- added JP1: SolderJumper_3_Open, Jumper:SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm, B.Cu at (133.3, 17.3)
- added L1: 2.2uH, ASPIAIG-F5030-2R2M-T:IND_ASPIAIG-F5030-2R2M-T, F.Cu at (72.0, 12.5)
- added L3: LQG15HS47NJ02D, LQG15HS47NJ02D:INDC1005X55N, F.Cu at (145.8, 0.20)
- added Q1: SI1016CX-T1-GE3, LIB_SI1016CX-T1-GE3:SOTFL50P160X60-6N, F.Cu at (147.3, 8.46)
- added Q2: MMBT3904LT1G, MMBT3904LT1G:SOT95P240X111-3N, F.Cu at (152.7, 11.2)
- added R17: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (107.8, 43.5)
- added R2: 5.1K, Resistor_SMD:R_0402_1005Metric, B.Cu at (60.2, 31.8)
- added R21: 6.49K, Resistor_SMD:R_0402_1005Metric, F.Cu at (125.2, 31.5)
- added R23: 470R, Resistor_SMD:R_0402_1005Metric, F.Cu at (127.3, 38.9)
- added R25: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (110.7, 43.5)
- added R3: 5.1K, Resistor_SMD:R_0402_1005Metric, B.Cu at (60.0, 1.97)
- added R34: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (110.1, -8.12)
- added R35: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (110.1, -14.1)
- added R4: 5.1K, Resistor_SMD:R_0402_1005Metric, B.Cu at (60.0, 4.97)
- added R43: 10K, Resistor_SMD:R_0402_1005Metric, B.Cu at (107.8, 30.4)
- added R66: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (119.4, 0.45)
- added R78: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (119.5, -1.23)
- added R93: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (110.1, -12.1)
- added U14: TPS22946YZPR, TPS22946YZPR:BGA6C50P2X3_140X90X50, F.Cu at (152.5, 8.03)
- added U9: LM66200DRLR, GNSS:SOT-5X3_DRL_TEX-M, F.Cu at (65.9, 17.0)
- A1, C11, C13, C22, C23, C43, C46, C48, C51, C69, C75, C76, C78, J3, R1, R5, R7, R87, R88, TP12, U5, U6: moved to B.Cu
- C52: value 1uF -> 100n; footprint Capacitor_SMD:C_0805_2012Metric -> Capacitor_SMD:C_0402_1005Metric
- C79: footprint Capacitor_SMD:C_0805_2012Metric -> Capacitor_SMD:C_0402_1005Metric
- D3: footprint GNSS:ESD5V0D5TP -> LIB_ESD5V0D5-TP:ESD5V0D5TP
- D7: footprint GNSS:SOT95P230X110-3N -> LIB_PESD2CANFD24V-TR:SOT95P230X110-3N; moved to B.Cu
- R16, R26, R44, R45, R68, R69, R70, R72, R73, R74, R75, R94: footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric; moved to B.Cu
- R18, R19, R20, R22, R27, R28, R29, R30, R33, R42, R48, R49, R50, R51, R62, R63, R64, R65, R67, R71, R76, R79, R83, R84, R85, R86, R9, R92: footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric
- R24, R52, R53, R54, R61: value 10]K -> 10K; footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric
- R55, R56, R57, R58, R59, R60: value 10]K -> 10K; footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric; moved to B.Cu
- moved TP4 158.6 mm to (129.2, -20.8)
- moved R86 153.2 mm to (153.7, 5.78), turned to 90 degrees
- moved C26 153.2 mm to (114.1, 1.31), turned to 180 degrees
- moved R83 151.4 mm to (144.6, 9.78), turned to 180 degrees
- moved R85 150.4 mm to (152.7, 5.75), turned to 90 degrees
- moved C25 149.6 mm to (114.1, 3.34)
- moved R84 147.5 mm to (151.6, 5.80), turned to 90 degrees
- moved R81 145.8 mm to (145.8, 4.86), turned to 90 degrees
- moved R32 144.5 mm to (145.8, 2.65), turned to -90 degrees
- moved VR1 144.3 mm to (109.8, 2.05), turned to 180 degrees
- moved R82 143.9 mm to (144.5, 8.38)
- moved R79 143.8 mm to (119.5, -2.50), turned to 180 degrees
- moved U10 139.9 mm to (100.7, 8.41), turned to 180 degrees
- moved R80 138.9 mm to (144.5, 10.9)
- moved TP12 138.8 mm to (114.6, 0.91), turned to 180 degrees
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Connections:
- R56 pad 1: SD_DAT3 -> SD_CMD
- R57 pad 1: SD_CMD -> SD_CLK
- R58 pad 1: SD_CLK -> SD_DAT0
- R59 pad 1: SD_DAT0 -> SD_DAT1
- R60 pad 1: SD_DAT1 -> SD_DETECT
- R61 pad 1: SD_DETECT -> INT1_ACCEL
- R61 pad 2: +3.3V_SD -> +3V3_IMU
- R76 pad 1: INT1_ACCEL -> INT1_GYRO
Routing:
- net ETH_MDIO: track 0.00 -> 44.5 mm
- net ETH_MDC: track 0.00 -> 38.8 mm
- net Net-(IC2-RF_IN): track 0.00 -> 25.4 mm
- net Net-(T1-TD+): track 0.00 -> 20.9 mm
- net Net-(T1-TD-): track 0.00 -> 19.2 mm
- net Net-(T1-RD+): track 0.00 -> 12.8 mm
- net Net-(Q2-B): track 0.00 -> 7.70 mm
- net Net-(Q1-D2): track 0.00 -> 5.79 mm
- net Net-(U13--IN): track 0.00 -> 2.97 mm
- net /ZED_Z9P/ANT_OFF: track 0.00 -> 2.94 mm
- net /ZED_Z9P/ON/OFF: track 0.00 -> 2.90 mm
- net GND: track 6.05 -> 3.91 mm, vias 0 -> 13
- net /ESP/CANH: track 0.00 -> 1.43 mm
- net USB_RST: track 0.00 -> 1.14 mm
Other:
- board outline added: 101 x 53.3 mm

Commit message: Almost Placed file
Parts:
- removed R17, R25, R34, R35, R66, R78, R93: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric
- added D10: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (115.3, 40.1)
- added D11: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (113.3, 40.1)
- added D12: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (111.4, 40.1)
- added D13: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (109.3, 40.1)
- added D14: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (107.4, 40.2)
- added D15: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (61.0, 15.2)
- added D16: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (61.0, 18.1)
- added L4: WE-CBF_0603, Resistor_SMD:R_0201_0603Metric, F.Cu at (148.9, 7.83)
- added S3: SKRPABE010, GNSS:SW_SKRPABE010, F.Cu at (102.4, 37.0)
- added U13: LT6000IDCB_TRMPBF, GNSS:DFN-6_DCB, F.Cu at (147.5, 16.5)
- added Y1: MURATA_XRCGB24M000FFS1DR0, GNSS:MURATA_XRCGB24M000FFS1DR0_0, F.Cu at (70.5, 26.1)
- C28, C31: moved to F.Cu
- C61, C64, R13, R23, R48, R51, R6, R9: moved to B.Cu
- Q1: footprint LIB_SI1016CX-T1-GE3:SOTFL50P160X60-6N -> GNSS:SOTFL50P160X60-6N
- S1: value TL3301EF100QG -> SKRPABE010; footprint GNSS:SOIC450P1000X730-4N -> GNSS:SW_SKRPABE010
- moved A1 118.4 mm to (118.7, -4.36), turned to 180 degrees
- moved S1 82.5 mm to (96.7, 36.9), turned to 90 degrees
- moved R60 56.8 mm to (64.9, -5.45)
- moved J3 50.3 mm to (74.3, 0.67), turned to 0 degrees
- moved R55 42.4 mm to (71.7, 10.1), turned to -90 degrees
- moved R67 40.8 mm to (111.3, 36.1), turned to -90 degrees
- moved R43 40.5 mm to (72.8, 10.1), turned to -90 degrees
- moved R79 39.9 mm to (109.2, 36.1), turned to -90 degrees
- moved R56 38.6 mm to (73.9, 10.1), turned to -90 degrees
- moved FL5 37.7 mm to (72.8, 14.5), turned to -90 degrees
- moved C75 36.7 mm to (75.0, 10.1), turned to 90 degrees
- moved R57 34.9 mm to (76.1, 10.2), turned to -90 degrees
- moved R33 33.5 mm to (107.3, 36.1)
- moved R89 32.5 mm to (76.3, 18.7)
- moved C76 32.3 mm to (75.0, 14.5), turned to -90 degrees
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Connections:
- R46 pad 1: 5V -> /Power/EN
- R47 pad 2: 5V -> /Power/EN
- S1 pad 2: unconnected-(S1-Pad2) -> /Controller/USER_BUT
- S1 pad 3: unconnected-(S1-Pad3) -> GND
- U7 pad 5: 5V -> /Power/EN
Routing:
- net ETH_MDIO: track 44.5 -> 0.00 mm
- net ETH_MDC: track 38.8 -> 0.00 mm
- net ARDUINO_RST_BUT: track 0.00 -> 5.46 mm
- net SD_CLK: track 0.00 -> 3.44 mm
- net +3.3V_SD: track 0.00 -> 3.44 mm
- net SD_DAT1: track 0.00 -> 3.40 mm
- net SD_DAT3: track 0.00 -> 3.40 mm
- net SD_DAT0: track 0.00 -> 3.38 mm
- net SD_CMD: track 0.00 -> 3.36 mm
- net SD_DAT2: track 0.00 -> 2.81 mm
- net /Power/EN: track 0.00 -> 2.29 mm
- net (no net): vias 0 -> 3
Other:
- outline, holes or cut-outs redrawn
- board text added: "USER BT1"

Commit message: new placed
Parts:
- removed FL9: BLM21PG221SN1D, BLM21PG221SN1D:BEADC2012X105N
- removed TP10, TP11, TP8, TP9: TestPoint, TestPoint:TestPoint_Pad_D2.0mm
- C70, C82, R27, R30, R42: moved to B.Cu
- FL6: moved to F.Cu
- R31: footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric
- R36, R37, R38, R39, R40, R41: footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0402_1005Metric; moved to B.Cu
- moved R18 103.7 mm to (101.2, -22.1)
- moved R31 103.7 mm to (101.2, -19.2)
- moved R92 103.7 mm to (101.2, -16.2)
- moved TP6 95.1 mm to (108.4, -21.1)
- moved TP7 95.1 mm to (108.4, -17.1)
- moved TP1 79.4 mm to (112.8, -21.0)
- moved TP2 79.4 mm to (112.8, -16.9)
- moved R36 75.4 mm to (128.0, 41.4), turned to 90 degrees
- moved R37 73.9 mm to (125.8, 41.4), turned to 90 degrees
- moved R19 73.2 mm to (117.8, -23.2)
- moved R20 73.2 mm to (124.8, -19.3)
- moved R41 71.4 mm to (117.6, 40.2), turned to 90 degrees
- moved R40 68.0 mm to (115.3, 40.2), turned to 90 degrees
- moved R42 66.0 mm to (96.3, 8.60)
- moved TP3 64.6 mm to (124.0, -14.8)
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Routing:
- net TX_READY: track 0.00 -> 91.6 mm, vias 0 -> 1
- net GN_TIMEPULSE: track 0.00 -> 56.7 mm
- net ESP_RXD: track 0.00 -> 52.3 mm
- net ESP_TXD: track 0.00 -> 48.2 mm
- net ETH_MDC: track 0.00 -> 45.3 mm
- net RESET_GNSS: track 0.00 -> 43.5 mm, vias 0 -> 1
- net SD_DAT2: track 2.81 -> 46.2 mm
- net STM_D_N: track 0.00 -> 39.7 mm, vias 0 -> 2
- net SD_DAT3: track 3.40 -> 41.8 mm
- net STM_D_P: track 0.00 -> 37.9 mm, vias 0 -> 2
- net GN_CS: track 0.00 -> 34.3 mm, vias 0 -> 1
- net GN_SCK: track 0.00 -> 33.6 mm, vias 0 -> 1
- net GN_MOSI: track 0.00 -> 33.4 mm, vias 0 -> 1
- net GN_MISO: track 0.00 -> 33.0 mm, vias 0 -> 1
- net ETH_RX_D1_N: track 0.00 -> 32.1 mm
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
Commit message: 14.09.2026
Parts:
- removed C79: 10uF, Capacitor_SMD:C_0402_1005Metric
- removed C81: 1uF, Capacitor_SMD:C_0805_2012Metric
- removed C82: 0.1uF, Capacitor_SMD:C_0402_1005Metric
- removed D10, D12, D13, D14, D15, D16: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric
- removed F2: MF-MSMF200-2, GNSS:FUSC4632X85N
- removed J4: SMA-J-P-X-RA-TH1, GNSS:SAMTEC_SMA-J-P-X-RA-TH1
- removed L3: LQG15HS47NJ02D, LQG15HS47NJ02D:INDC1005X55N
- removed Q2: MMBT3904LT1G, MMBT3904LT1G:SOT95P240X111-3N
- removed R67: 560R, Resistor_SMD:R_0402_1005Metric
- removed R72, R73: 22E, Resistor_SMD:R_0402_1005Metric
- removed R80, R81, R82, R85, R86: 10K, Resistor_SMD:R_0402_1005Metric
- removed S3: SKRPABE010, GNSS:SW_SKRPABE010
- removed U11: TPD2EUSB30ADRTR, GNSS:SOTFL35P100X50-3N
- removed U14: TPS22946YZPR, TPS22946YZPR:BGA6C50P2X3_140X90X50
- removed Y2: ECS-250-12-33-AGN-TR, GNSS:XTAL_ECS-250-12-33-AGN-TR
- added C53: 10uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (127.2, 133.1)
- added D2: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (112.2, 132.5)
- added D5: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (112.2, 134.5)
- added D6: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (112.2, 136.5)
- added D8: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (112.2, 138.5)
- added D9: SML-P12U2TT86R, LED_SMD:LED_0402_1005Metric, F.Cu at (112.2, 140.5)
- added J8: USB_C_Receptacle_USB2.0_16P, Connector_USB:USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A, F.Cu at (97.8, 83.2)
- added Q3: BC849, Package_TO_SOT_SMD:SOT-23, F.Cu at (108.0, 133.9)
- added Q5: BC849, Package_TO_SOT_SMD:SOT-23, F.Cu at (108.0, 138.6)
- added Q6: BC849, Package_TO_SOT_SMD:SOT-23, F.Cu at (108.0, 143.2)
- added Q7: BC849, Package_TO_SOT_SMD:SOT-23, F.Cu at (108.0, 147.8)
- added Q8: BC849, Package_TO_SOT_SMD:SOT-23, F.Cu at (108.0, 152.4)
- added R100: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 142.5)
- added R17: 60R, Resistor_SMD:R_0805_2012Metric, F.Cu at (122.7, 133.0)
- added R25: 10K, Resistor_SMD:R_0805_2012Metric, F.Cu at (122.7, 136.0)
- added R34: 22E, Resistor_SMD:R_0805_2012Metric, F.Cu at (122.7, 138.9)
- added R35: 10K, Resistor_SMD:R_0805_2012Metric, F.Cu at (122.7, 141.9)
- added R66: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 146.5)
- added R77: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 148.5)
- added R78: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 150.5)
- added R93: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 152.5)
- added R95: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 132.5)
- added R96: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 134.5)
- added R97: 10R, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 136.5)
- added R98: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 138.5)
- added R99: 10K, Resistor_SMD:R_0402_1005Metric, F.Cu at (117.1, 140.5)
- C1, C2: value 18pF -> 18p
- C10, C25, C43: value 4.7uF -> 4u7
- C11, C13, C45, C46, C48, C51, C55, C57, C58, C62, C72: value 1uF -> 1u
- C12, C14, C18, C21, C3, C4, C5, C6, C7, C8, C83, C84, C9: value 0.1uF -> 0.1u
- C15, C16, C19, C20: value 22uF -> 22u
- C17: value 220pF -> 220p
- C22: value 10uF -> 100n; footprint Capacitor_SMD:C_0805_2012Metric -> Capacitor_SMD:C_0402_1005Metric
- C23: value 10uF -> 4u7
- C24: value 0.47 -> 0.47u
- C26: value 10uF -> 10u
- C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C44, C47, C49, C50, C56, C59, C60, C63: value 100nF -> 100n
- C61, C64: value 10nF -> 10n
- C66: value 15pF -> 18p
- C67: value 2.2uF -> 1uF
- C68: value 4.7nF -> 100n; footprint C0402C104K4RAC:CAPC1005X55N -> Capacitor_SMD:C_0402_1005Metric
- C69: value 100nF -> 10n
- C70: value 4.7uF -> 2u2
- C71: value GRM033R71C103KE14D -> 0.1u; footprint GRM033R71C103KE14D:CAPC0603X33N -> Capacitor_SMD:C_0402_1005Metric
- C73: value 100pF -> 100n; footprint C0402C104K4RAC:CAPC1005X55N -> Capacitor_SMD:C_0402_1005Metric
- C74: value 100pF -> 10u; footprint C0402C104K4RAC:CAPC1005X55N -> Capacitor_SMD:C_0805_2012Metric
- C77: value 100nF -> 18p
- C80: value 100nF -> 100n; moved to B.Cu
- D1: value PESD0402-140 -> SML-P12U2TT86R; footprint PESD0402-140:DIO_PESD0402-140 -> LED_SMD:LED_0402_1005Metric
- D3: footprint LIB_ESD5V0D5-TP:ESD5V0D5TP -> GNSS:ESD5V0D5TP
- D7: value PESD2CANFD24V-TR -> SML-P12U2TT86R; footprint LIB_PESD2CANFD24V-TR:SOT95P230X110-3N -> LED_SMD:LED_0402_1005Metric
- FL12: moved to B.Cu
- J1: value USB4105-GF-A -> USB_C_Receptacle_USB2.0_16P; footprint GNSS:USB4105_GCT -> Connector_USB:USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
- J2: value USB4105-GF-A -> Conn; footprint GNSS:USB4105_GCT -> Connector_PinHeader_1.00mm:PinHeader_1x03_P1.00mm_Vertical
- J7: value Conn -> SMA-J-P-X-RA-TH1; footprint Connector_PinHeader_1.00mm:PinHeader_1x03_P1.00mm_Vertical -> GNSS:SAMTEC_SMA-J-P-X-RA-TH1
- L1: value 2.2uH -> 2.2u
- R1, R2, R3, R4: value 5.1K -> 5K1
- R11: value 16.5K -> 16K5
- R12: value 2.94K -> 2K94
- R13: value 49.9K -> 49K9
- R14: value 33.2K -> 33K2
- R16, R43, R52, R53, R54: footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0805_2012Metric
- R18, R28, R29, R33: value 560R -> 560E
- R21: value 6.49K -> 6K49
- R22: value 22E -> 1M
- R24: value 10K -> 22E; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0805_2012Metric
- R26: value 60R -> 10K; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0805_2012Metric
- R30, R44, R59: value 10K -> 560E
- R32: value 10E -> 10K
- R36, R37: value 4.7K -> 4K7
- R46: value 32.4K -> 32K4
- R49, R50: value 2.2K -> 2K2
- R57: value 10K -> 1M
- R62, R63, R64, R65, R68, R69: value 10]K -> 10K
- R79, R92: value 560R -> 10K
- R91: value 1Meg -> 1M
- U1: value ICM-42688-P -> MIC5205-3.3YM5; footprint GNSS:PQFN50P300X250X97-14N -> Package_TO_SOT_SMD:SOT-23-5
- U10, U12, U2: value TPD2EUSB30ADRTR -> TPD2EUSB30A; footprint GNSS:SOTFL35P100X50-3N -> Package_TO_SOT_SMD:Texas_DRT-3
- U13: value LT6000IDCB_TRMPBF -> ICM-42688-P; footprint GNSS:DFN-6_DCB -> GNSS:PQFN50P300X250X97-14N
- U3: value ESP32-C3-MINI-1-N4 -> TPD2EUSB30A; footprint GNSS:XCVR_ESP32-C3-MINI-1-N4 -> Package_TO_SOT_SMD:Texas_DRT-3
- U6: value ADP150WACBZ-3.3-R7 -> TPD2EUSB30A; footprint GNSS:CB-4-3_ADI -> Package_TO_SOT_SMD:Texas_DRT-3
- U8: value ECS-TXO-2520-33-240-AN-TR -> ESP32-C3-MINI-1-N4; footprint GNSS:ECS-TXO-2520-33-240-AN-TR_ECS -> GNSS:XCVR_ESP32-C3-MINI-1-N4
- U9: value LM66200DRLR -> MCP6001-OT; footprint GNSS:SOT-5X3_DRL_TEX-M -> Package_TO_SOT_SMD:SOT-23-5
- moved C44 129.6 mm to (153.7, 95.0)
- moved C47 129.6 mm to (153.7, 97.1)
- moved C49 129.6 mm to (153.7, 99.2)
- moved C50 129.6 mm to (153.7, 101.2)
- moved C77 127.7 mm to (153.7, 103.2)
- moved J7 111.3 mm to (191.8, 77.5), turned to 180 degrees
- moved U8 106.3 mm to (113.3, 119.0), turned to 180 degrees
- moved C11 86.4 mm to (112.4, 103.3)
- moved C14 86.4 mm to (113.5, 104.4)
- moved C17 86.4 mm to (108.3, 84.0)
- moved C2 86.4 mm to (110.2, 100.9)
- moved C22 86.4 mm to (128.4, 83.1)
- moved C24 86.4 mm to (157.2, 93.0)
- moved C27 86.4 mm to (164.6, 105.6)
- moved C28 86.4 mm to (121.5, 117.5)
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Connections:
- net /Controller/BOOT0 renamed /CONTROLLER/BOOT0
- net /Power/EN renamed /POWER/EN
- net /Power/SW renamed /POWER/SW
- C22 pad 1: +3V3_BMI -> GND
- C22 pad 2: GND -> VIN_CAN
- C23 pad 1: VIN_BMI -> VIN_CAN
- C66 pad 1: GND -> /ETHERNET/XTAL_OUT
- C66 pad 2: Net-(C66-Pad2) -> GND
- C67 pad 1: +3V3_IMU -> ESP_EN
- C68 pad 2: Net-(C68-Pad2) -> +3V3_IMU
- C69 pad 1: unconnected-(C69-Pad1) -> GND
- C69 pad 2: VIN_CAN -> +3V3_IMU
- C70 pad 1: VIN_CAN -> +3V3_IMU
- C71 pad 2: Net-(U13--IN) -> RST_BUT
- C73 pad 2: /ESP/CANH -> +3.3V_SD
- C74 pad 1: GND -> +3.3V_SD
- C74 pad 2: /ESP/CANL -> GND
- C77 pad 1: GND -> /ETHERNET/XTAL_IN
- C77 pad 2: STM_3.3V -> GND
- D1 pad 2: Net-(IC2-RF_IN) -> Net-(D1-Pad2)
- D7 pad 1: /ESP/CANH -> Net-(Q6-C)
- D7 pad 2: /ESP/CANL -> Net-(D7-Pad2)
- FL1 pad 1: +3.3V_ESP -> VIN_CAN
- FL1 pad 2: +3.3V -> VIN
- FL2 pad 1: VIN_CAN -> +3.3V_CAN
- FL2 pad 2: VIN -> +3.3V
- FL3 pad 1: +3.3V_CAN -> +3.3V_ESP
- FL4 pad 2: +3V3_BMI -> +3V3_ICM
- FL7 pad 2: VIN_BMI -> VIN_ICM
- IC2 pad 19: /ZED_Z9P/GEOFENCE -> GEOFENCE
- IC2 pad 2: Net-(IC2-RF_IN) -> RF_IN
- IC2 pad 20: /ZED_Z9P/RTK_STAT -> RTK_STAT
- IC2 pad 4: Net-(IC2-ANT_DETECT) -> ANT_DETECT
- IC2 pad 5: /ZED_Z9P/ANT_OFF -> ANT_OFF
- IC2 pad 6: /ZED_Z9P/ANT_SHORT_N -> ANT_SHORT_N
- IC3 pad 12: /Controller/OSC -> /CONTROLLER/OSC_IN
- IC3 pad 13: unconnected-(IC3-PH1-OSC_OUT-Pad13) -> /CONTROLLER/OSC_OUT
- IC3 pad 84: /Controller/GN_LED -> GN_LED
- IC3 pad 85: /Controller/USER_BUT -> USER_BUT
- IC3 pad 86: /Controller/USER_LED -> USER_LED
- J1 pad A6: DP -> unconnected-(J1-D+-PadA6)
- J1 pad A7: DN -> unconnected-(J1-D--PadA7)
- J1 pad B6: DP -> unconnected-(J1-D+-PadB6)
- J1 pad B7: DN -> unconnected-(J1-D--PadB7)
- J7 pad 1: /ESP/CANH -> RF_IN
- J7 pad 2: /ESP/CANL -> GND
- R1 pad 1: Net-(J1-CC1) -> Net-(J8-CC2)
- R16 pad 1: Net-(C68-Pad2) -> Net-(C29-Pad2)
- R16 pad 2: /ESP/CANH -> /ESP & CAN/CANH
- R18 pad 1: PG_VBUS -> STM_3.3V
- R2 pad 2: Net-(J1-CC2) -> Net-(J8-CC1)
- R22 pad 1: /Controller/OSC -> /ETHERNET/XTAL_IN
- R22 pad 2: Net-(C66-Pad2) -> /ETHERNET/XTAL_OUT
- R24 pad 1: IMU_CS -> ESP_TXD
- R24 pad 2: +3V3_IMU -> Net-(U8-RXD0)
- R26 pad 1: Net-(C68-Pad2) -> +3.3V_ESP
- R26 pad 2: /ESP/CANL -> Net-(U8-IO2)
- R27 pad 1: RST_BUT -> Net-(Q3-B)
- R27 pad 2: STM_3.3V -> USER_LED
- R28 pad 1: /Controller/USER_LED -> EX_VBUS
- R28 pad 2: Net-(D11-Pad2) -> Net-(D1-Pad2)
- R29 pad 1: /Controller/GN_LED -> STM_3.3V
- R3 pad 1: Net-(J2-CC1) -> Net-(J1-CC1)
- R30 pad 1: /Controller/USER_BUT -> +3V3_GN
- R30 pad 2: STM_3.3V -> Net-(D7-Pad2)
- R31 pad 1: Net-(U9-ST) -> Net-(IC4-ST)
- R32 pad 1: Net-(U13--IN) -> Net-(Q5-B)
- R32 pad 2: Net-(Q1-D2) -> GN_LED
- R33 pad 1: GN_TIMEPULSE -> PG_VBUS
- R4 pad 1: Net-(J2-CC2) -> Net-(J1-CC2)
- R43 pad 1: SD_DAT3 -> ESP_RXD
- R43 pad 2: +3.3V_SD -> +3.3V_ESP
- R44 pad 1: +3.3V_ESP -> +3V3_GN
- R44 pad 2: Net-(U3-IO2) -> Net-(D8-Pad2)
- R45 pad 1: +3.3V_ESP -> Net-(Q6-B)
- R45 pad 2: /ESP/IO8 -> GN_TIMEPULSE
- R52 pad 1: IMU_SCK -> ESP_BOOT
- R52 pad 2: +3V3_IMU -> +3.3V_ESP
- R53 pad 1: IMU_MOSI -> ESP_EN
- R53 pad 2: +3V3_IMU -> +3.3V_ESP
- R54 pad 1: IMU_MISO -> +3.3V_ESP
- R54 pad 2: +3V3_IMU -> /ESP & CAN/IO8
- R55 pad 1: SD_DAT2 -> IMU_CS
- R55 pad 2: +3.3V_SD -> +3V3_IMU
- R56 pad 1: SD_CMD -> IMU_SCK
- R56 pad 2: +3.3V_SD -> +3V3_IMU
- R57 pad 1: SD_CLK -> /CONTROLLER/OSC_IN
- R57 pad 2: +3.3V_SD -> /CONTROLLER/OSC_OUT
- R58 pad 1: SD_DAT0 -> USER_BUT
- R58 pad 2: +3.3V_SD -> STM_3.3V
- R59 pad 1: SD_DAT1 -> +3V3_GN
- R59 pad 2: +3.3V_SD -> Net-(D9-Pad2)
- R60 pad 1: SD_DETECT -> Net-(Q7-B)
- R60 pad 2: +3.3V_SD -> RTK_STAT
- R61 pad 1: INT1_ACCEL -> IMU_MOSI
- R70 pad 1: ESP_EN -> RST_BUT
- R70 pad 2: +3.3V_ESP -> STM_3.3V
- R71 pad 1: +3.3V_ESP -> Net-(Q8-B)
- R71 pad 2: ESP_INT -> GEOFENCE
- R74 pad 1: ESP_TXD -> INT1_ACCEL
- R74 pad 2: +3.3V_ESP -> +3V3_IMU
- R75 pad 1: ESP_RXD -> INT1_GYRO
- R75 pad 2: +3.3V_ESP -> +3V3_IMU
- R76 pad 1: INT1_GYRO -> SD_DAT2
- R76 pad 2: +3V3_IMU -> +3.3V_SD
- R79 pad 1: /ZED_Z9P/RTK_STAT -> SD_CLK
- R79 pad 2: Net-(D13-Pad2) -> +3.3V_SD
- R83 pad 2: /ZED_Z9P/ANT_OFF -> ANT_OFF
- R84 pad 2: /ZED_Z9P/ON/OFF -> ON/OFF
- R92 pad 1: /Power/EX_VBUS -> SD_DAT0
- R92 pad 2: Net-(D16-Pad2) -> +3.3V_SD
- R94 pad 1: ESP_BOOT -> SD_DETECT
- R94 pad 2: +3.3V_ESP -> +3.3V_SD
- S1 pad 1: /Controller/USER_BUT -> USER_BUT
- S1 pad 2: /Controller/USER_BUT -> USER_BUT
- TP1 pad 1: Net-(U9-ST) -> Net-(IC4-ST)
- TP3 pad 1: ESP_BOOT -> +3V3_ICM
- TP4 pad 1: +3V3_BMI -> ESP_BOOT
- U1 pad 1: IMU_MISO -> VIN_ICM
- U1 pad 2: unconnected-(U1-RESV_2-Pad2) -> GND
- U1 pad 3: unconnected-(U1-RESV_3-Pad3) -> VIN_ICM
- U1 pad 4: INT1_ACCEL -> Net-(U1-BP)
- U1 pad 5: +3V3_IMU -> +3V3_ICM
- U10 pad 1: GNSS_D_P -> ESP_D_P
- U10 pad 2: GNSS_D_N -> ESP_D_N
- U12 pad 1: ESP_D_P -> STM_D_P
- U12 pad 2: ESP_D_N -> STM_D_N
- U13 pad 1: RF_VCC -> IMU_MISO
- U13 pad 2: Net-(U13--IN) -> unconnected-(U13-RESV_2-Pad2)
- U13 pad 3: /ZED_Z9P/ANT_SHORT_N -> unconnected-(U13-RESV_3-Pad3)
- U13 pad 4: Net-(IC2-ANT_DETECT) -> INT1_ACCEL
- U13 pad 5: GND -> +3V3_IMU
- U13 pad 6: RF_VCC -> GND
- U13 pad 7: GND -> unconnected-(U13-RESV_7-Pad7)
- U3 pad 1: GND -> GNSS_D_P
- U3 pad 2: GND -> GNSS_D_N
- U3 pad 3: +3.3V_ESP -> GND
- U4 pad 12: /Ethernet/XTAL_OUT -> /ETHERNET/XTAL_OUT
- U4 pad 13: /Ethernet/XTAL_IN -> /ETHERNET/XTAL_IN
- U5 pad 1: CAN_TXD -> unconnected-(U5-TXD-Pad1)
- U5 pad 2: GND -> unconnected-(U5-GND-Pad2)
- U5 pad 3: VIN_CAN -> unconnected-(U5-VCC-Pad3)
- U5 pad 4: CAN_RXD -> unconnected-(U5-RXD-Pad4)
- U5 pad 5: +3.3V_CAN -> unconnected-(U5-VIO-Pad5)
- U5 pad 6: /ESP/CANL -> unconnected-(U5-CANL-Pad6)
- U5 pad 7: /ESP/CANH -> unconnected-(U5-CANH-Pad7)
- U5 pad 8: CAN_STB -> unconnected-(U5-STB-Pad8)
- U5 pad 9: GND -> unconnected-(U5-PAD-Pad9)
- U8 pad 1: STM_3.3V -> GND
- U8 pad 3: Net-(C66-Pad2) -> +3.3V_ESP
- U8 pad 4: STM_3.3V -> unconnected-(U8-NC-Pad4)
- U9 pad 1: GND -> ANT_DETECT
- U9 pad 2: VIN -> GND
- U9 pad 3: PG_VBUS -> ANT_SHORT_N
- U9 pad 4: GND -> Net-(U9--)
- U9 pad 5: GND -> RF_VCC
Routing:
- net ESP_RXD: track 52.3 -> 0.00 mm
- net INT1_GYRO: track 22.1 -> 74.4 mm
- net ESP_TXD: track 48.2 -> 0.00 mm
- net INT1_ACCEL: track 14.1 -> 62.3 mm
- net ESP_INT: track 23.0 -> 0.92 mm
- net GEOFENCE: track 0.00 -> 22.1 mm
- net (no net): track 0.00 -> 4.85 mm
- net Net-(U8-TXD0): track 0.00 -> 4.49 mm, vias 0 -> 1
- net Net-(U3-RXD0): track 4.49 -> 0.00 mm, vias 1 -> 0
- net unconnected-(U8-NC-Pad32): track 0.00 -> 4.25 mm, vias 0 -> 1
- net Net-(U3-TXD0): track 4.25 -> 0.00 mm, vias 1 -> 0
- net /ZED_Z9P/ON/OFF: track 2.90 -> 0.00 mm
- net +3.3V_ESP: track 0.00 -> 2.31 mm
- net VIN_CAN: track 2.25 -> 0.00 mm
- net /Controller/OSC: track 1.95 -> 0.00 mm
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