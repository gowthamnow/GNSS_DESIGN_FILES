File: Block_Diagram_sch.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Add the STM
Other:
- note added: "Connections Overview"
